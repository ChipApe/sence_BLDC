# Keil uVision project lks03x_foc_open_Senseless.uvprojx, settings and files
target lks03x_foc_open_Senseless (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC031KLC6T8B Linko
  pack: Linko.LKS03x.1.1.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lks03x_foc_open_Senseless
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c include: .\Include;.\periph_driver\Include;.\User
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group periph_driver
    ./periph_driver/Source/: lks32mc03x_adc.c lks32mc03x_dsp.c lks32mc03x_gpio.c lks32mc03x_iwdg.c lks32mc03x_mcpwm.c lks32mc03x_opa.c lks32mc03x_sys.c startup_lks32mc03x.s lks32mc03x_nvr.lib
  group app_func
    ./User/app_func/: hardware_init.c interrupt.c main.c
  group kernel_source
    ./User/foc_kernel/source/: _math.c _spi.c mt6816.c pid.c mc.c mc_variable.c sys_state.c smo.c
  group include
    ./User/foc_kernel/include/: mc_type.h _math.h mc_variable.h config.h mc.h
  group SEGGER_RTT
    ./User/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.5.0
